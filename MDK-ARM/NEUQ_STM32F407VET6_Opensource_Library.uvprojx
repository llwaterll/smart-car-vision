# Keil uVision project NEUQ_STM32F407VET6_Opensource_Library.uvprojx, settings and files
target NEUQ_STM32F407VET6_Opensource_Library (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: NEUQ_STM32F407VET6_Opensource_Library +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --locale=english
  c include: .;../Library/HAL_lib/Core/Inc;../Library/HAL_lib/STM32F4xx_HAL_Driver/Inc;../Library/HAL_lib/STM32F4xx_HAL_Driver/Inc/Legacy;../Library/NEUQ_lib;../Library/NEUQ_lib/NEUQ_lib_APP;../Library/NEUQ_lib/NEUQ_lib_Debug;../Library/NEUQ_lib/NEUQ_lib_Device;../Library/NEUQ_lib/NEUQ_lib_Driver;../User;../CODE
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group ..\Library\HAL_lib\Core\Src
    ../Library/HAL_lib/Core/Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c
  group ..\Library\HAL_lib\STM32F4xx_HAL_Driver\Src
    ../Library/HAL_lib/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_fmpsmbus.c stm32f4xx_hal_fmpsmbus_ex.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_mmc.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_smbus.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_adc.c stm32f4xx_ll_crc.c stm32f4xx_ll_dac.c stm32f4xx_ll_dma.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_exti.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fmpi2c.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_gpio.c stm32f4xx_ll_i2c.c stm32f4xx_ll_lptim.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_rng.c stm32f4xx_ll_rtc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c stm32f4xx_ll_usb.c stm32f4xx_ll_utils.c
  group ..\Library\NEUQ_lib\NEUQ_lib_APP
    ../Library/NEUQ_lib/NEUQ_lib_APP/: NEUQ_Filter.c NEUQ_IMU_Solve.c NEUQ_PID.c
  group ..\Library\NEUQ_lib\NEUQ_lib_Debug
    ../Library/NEUQ_lib/NEUQ_lib_Debug/: NEUQ_Assert.c NEUQ_Debug_ZF_Interface.c NEUQ_UART_Debug.c
  group ..\Library\NEUQ_lib\NEUQ_lib_Device
    ../Library/NEUQ_lib/NEUQ_lib_Device/: NEUQ_LCD200.c NEUQ_MPU6050.c NEUQ_OV5640.c NEUQ_OV7725.c NEUQ_OV9281.c
  group ..\Library\NEUQ_lib\NEUQ_lib_Driver
    ../Library/NEUQ_lib/NEUQ_lib_Driver/: NEUQ_ADC.c NEUQ_CONSTS.c NEUQ_Delay.c NEUQ_EXTI.c NEUQ_Encoder.c NEUQ_FIFO.c NEUQ_Flash.c NEUQ_GPIO.c NEUQ_Hard_IIC.c NEUQ_Hard_SPI.c NEUQ_PIT.c NEUQ_PWM.c NEUQ_Soft_IIC.c NEUQ_Soft_SPI.c NEUQ_Timer.c NEUQ_Uart.c
  group ..\User
    ../User/: NEUQ_Interrupts.c NEUQ_Main.c
  group CODE
    ../CODE/: Board_Config.h Menu_Task.c Menu_Task.h Drv_Motor.c Drv_Motor.h Drv_Encoder.c Drv_Encoder.h Drv_Key.c Drv_Key.h Drv_Lcd.c Drv_Lcd.h Drv_Lcd_FontZh.h Drv_Gyro.c Drv_Gyro.h Drv_Battery.c Drv_Battery.h Drv_Clock.c Drv_Clock.h Drv_Uart.c Drv_Uart.h Proto_Bluetooth.c Proto_Bluetooth.h Proto_Vision.c Proto_Vision.h Proto_VisionStatus.c Proto_VisionStatus.h Proto_Vofa.c Proto_Vofa.h Pid.c Pid.h Pid_Storage.c Pid_Storage.h Sudoku.c Sudoku.h Task_Fsm.c Task_Fsm.h Track_Fsm.c Track_Fsm.h Platform_Main.c Platform_Main.h
  group .
    ./: startup_stm32f407xx.s
